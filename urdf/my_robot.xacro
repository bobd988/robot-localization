Commit message: v1.0

File: urdf/my_robot.xacro (robot description, xacro)
@@ -118,5 +118,5 @@
   </gazebo>
   <gazebo reference="right_wheel">
-    <material>Gazebo/Blue</material>
+    <material>Gazebo/Red</material>
   </gazebo>
   <joint type="continuous" name="left_wheel_hinge">
